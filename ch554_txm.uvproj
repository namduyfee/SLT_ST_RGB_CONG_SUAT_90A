# Keil uVision project ch554_txm.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: ch554_txm +hex
  c flags: Optimize=8
  c include: .\Project\include
  group Source Group 1
    ./: Debug.C Main.C
  group Project
    ./Project/Source/: Timer0.c Effect.c Savedata.c WriteFlashROM.c ADC.c Effect_RGBDance.c
